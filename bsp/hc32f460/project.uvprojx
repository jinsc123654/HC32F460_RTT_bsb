# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F460.1.0.8
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_DEVICE_DRIVER_LIB, __CLK_TCK=RT_TICK_PER_SECOND, HC32F460, __RTTHREAD__, __DEBUG, RT_USING_ARM_LIBC
  c misc: --diag_suppress=186,66
  c include: applications;.;..\..\components\net\at\include;..\..\components\net\at\at_socket;packages\at_device-latest\inc;packages\at_device-latest\class\esp8266;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;board;drivers;..\..\components\dfs\include;..\..\components\dfs\filesystems\devfs;..\..\components\finsh;Libraries\CMSIS\Include;Libraries\CMSIS\Device\HDSC\HC32F460\Include;Libraries\HC32F460_StdPeriph_Driver\inc;.;..\..\include;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\nogcc;..\..\components\net\netdev\include;..\..\components\net\sal_socket\include;..\..\components\net\sal_socket\include\socket;..\..\components\net\sal_socket\impl;..\..\components\net\sal_socket\include\socket\sys_socket;..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: SystemLight.c main.c
  group AT
    ../../components/net/at/src/: at_server.c at_base_cmd.c at_cli.c at_client.c at_utils.c
    ../../components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-latest/class/esp8266/: at_device_esp8266.c at_socket_esp8266.c
    packages/at_device-latest/samples/: at_sample_esp8266.c
    packages/at_device-latest/src/: at_device.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: workqueue.c dataqueue.c pipe.c ringblk_buf.c completion.c ringbuffer.c waitqueue.c
  group Drivers
    board/: board_config.c board.c
    drivers/: drv_gpio.c drv_irq.c drv_usart.c
  group Filesystem
    ../../components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    ../../components/dfs/filesystems/devfs/: devfs.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_file.c cmd.c
  group HC32_StdPeriph
    Libraries/CMSIS/Device/HDSC/HC32F460/Source/: system_hc32f460.c
    Libraries/HC32F460_StdPeriph_Driver/src/: hc32f460_usart.c hc32f460_gpio.c hc32f460_clk.c hc32f460_efm.c hc32f460_sram.c hc32f460_utility.c hc32f460_exint_nmi_swi.c hc32f460_icg.c hc32f460_interrupts.c hc32f460_pwc.c
    Libraries/CMSIS/Device/HDSC/HC32F460/Source/ARM/: startup_hc32f460.s
  group Kernel
    ../../src/: ipc.c timer.c components.c object.c clock.c mem.c irq.c device.c mempool.c thread.c idle.c scheduler.c kservice.c
  group libc
    ../../components/libc/compilers/armlibc/: syscalls.c libc_syms.c mem_std.c
    ../../components/libc/compilers/common/: time.c stdlib.c
  group SAL
    ../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../components/net/sal_socket/src/: sal_socket.c
    ../../components/net/sal_socket/impl/: af_inet_at.c
    ../../components/net/sal_socket/socket/: net_netdb.c
